options:
  parameters:
    author: Johannes Demel
    category: lte
    description: hierarchical blocks for PSS synchronization
    generate_options: hb
    id: lte_pss_sync
    output_language: python
    title: LTE PSS Sync
  states: {}

blocks:
- name: N_rb_dl_pss
  id: variable
  parameters:
    value: '6'
  states: {}
- name: band
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 9326e5
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 768e4
  states: {}
- name: fftlen
  id: parameter
  parameters:
    label: FFT length
    type: intx
    value: '2048'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: sync_pss_calculator_vcm_0
  id: lte_pss_calculator_vcm
  parameters:
    fftl: fftlen
  states: {}
- name: sync_pss_fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftlen
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(fftlen)
  states: {}
- name: sync_pss_lte_extract_subcarriers_vcvc_0
  id: lte_extract_subcarriers_vcvc
  parameters:
    N_rb_dl: N_rb_dl_pss
    fftl: fftlen
  states: {}
- name: sync_pss_symbol_selector_cvc_0
  id: lte_pss_symbol_selector_cvc
  parameters:
    fftl: fftlen
  states: {}
- name: sync_pss_tagger_cc_0
  id: lte_pss_tagger_cc
  parameters:
    fftl: fftlen
  states: {}

connections:
- [pad_source_0, '0', sync_pss_symbol_selector_cvc_0, '0']
- [pad_source_0, '0', sync_pss_tagger_cc_0, '0']
- [sync_pss_calculator_vcm_0, N_id_2, sync_pss_tagger_cc_0, N_id_2]
- [sync_pss_calculator_vcm_0, half_frame, sync_pss_symbol_selector_cvc_0, half_frame]
- [sync_pss_calculator_vcm_0, half_frame, sync_pss_tagger_cc_0, half_frame]
- [sync_pss_calculator_vcm_0, lock, sync_pss_symbol_selector_cvc_0, lock]
- [sync_pss_calculator_vcm_0, lock, sync_pss_tagger_cc_0, lock]
- [sync_pss_fft_vxx_0, '0', sync_pss_lte_extract_subcarriers_vcvc_0, '0']
- [sync_pss_lte_extract_subcarriers_vcvc_0, '0', sync_pss_calculator_vcm_0, '0']
- [sync_pss_symbol_selector_cvc_0, '0', sync_pss_fft_vxx_0, '0']
- [sync_pss_tagger_cc_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
