options:
  parameters:
    author: Kristian Maier, Johannes Demel
    category: Custom
    description: LTE decoding up to 4 tx antennas
    generate_options: qt_gui
    id: lte_top_block_mimo_4tx
    output_language: python
    title: MIMO TOP FLOW 4 Tx ant
  states: {}

blocks:
- name: N_rb_dl
  id: variable
  parameters:
    value: '50'
  states: {}
- name: fftl
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: frame_key
  id: variable
  parameters:
    value: '"slot"'
  states: {}
- name: resampler
  id: variable
  parameters:
    value: '400'
  states: {}
- name: rxant
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: fftl*15e3
  states: {}
- name: MIB
  id: lte_mib_unpack_vbm
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/maier/LTE test files/live data/lte_capture_Wed_Aug_6_19:36:39_2014_RXant2_4MS_telekom_band1800_wg_karlruhe_hinten raus_messung1.dat
    repeat: 'True'
    type: complex
    vlen: '2'
  states: {}
- name: blocks_streams_to_vector_0_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
    vlen: 12 * N_rb_dl
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '2'
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: complex
  states: {}
- name: lte_bch_decoder_0
  id: lte_bch_decoder
  parameters: {}
  states: {}
- name: lte_channel_estimator_mimo_4tx_0
  id: lte_channel_estimator_mimo_4tx
  parameters:
    N_rb_dl: N_rb_dl
    estimator_key: '"slot"'
    initial_id: '333'
    rxant: rxant
  states: {}
- name: lte_cp_ffo_sync_mimo_2tx_0
  id: lte_cp_ffo_sync_mimo_2tx
  parameters:
    fftlen: fftl
    rxant: rxant
  states: {state: disabled}
- name: lte_ofdm_demodulator_mimo_2tx_0
  id: lte_ofdm_demodulator_mimo_2tx
  parameters:
    N_rb_dl: N_rb_dl
    fftlen: fftl
    ofdm_key: '"slot"'
    rxant: rxant
  states: {}
- name: lte_pbch_decoder_mimo_4tx_0
  id: lte_pbch_decoder_mimo_4tx
  parameters:
    N_rb_dl: N_rb_dl
    rxant: rxant
  states: {}
- name: lte_pss_sync_direct_mimo_2tx_0
  id: lte_pss_sync_direct_mimo_2tx
  parameters:
    fftlen: fftl
    rxant: rxant
    synclen: '5'
  states: {}
- name: lte_sss_sync_freq_domain_mimo_2tx_0
  id: lte_sss_sync_freq_domain_mimo_2tx
  parameters:
    N_rb_dl: N_rb_dl
    rxant: rxant
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: resampler
    interp: 1536*fftl//1024
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: resampler
    interp: 1536*fftl//1024
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_streams_to_vector_0_0, '0', lte_channel_estimator_mimo_4tx_0, '0']
- [blocks_streams_to_vector_0_0, '0', lte_pbch_decoder_mimo_4tx_0, '0']
- [blocks_throttle_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_vector_to_streams_0, '0', rational_resampler_xxx_0_1, '0']
- [blocks_vector_to_streams_0, '1', rational_resampler_xxx_0_0, '0']
- [lte_bch_decoder_0, '0', MIB, '0']
- [lte_bch_decoder_0, '1', MIB, '1']
- [lte_channel_estimator_mimo_4tx_0, '0', lte_pbch_decoder_mimo_4tx_0, '1']
- [lte_channel_estimator_mimo_4tx_0, '1', lte_pbch_decoder_mimo_4tx_0, '2']
- [lte_channel_estimator_mimo_4tx_0, '2', lte_pbch_decoder_mimo_4tx_0, '3']
- [lte_channel_estimator_mimo_4tx_0, '3', lte_pbch_decoder_mimo_4tx_0, '4']
- [lte_cp_ffo_sync_mimo_2tx_0, '0', lte_ofdm_demodulator_mimo_2tx_0, '0']
- [lte_cp_ffo_sync_mimo_2tx_0, '1', lte_ofdm_demodulator_mimo_2tx_0, '1']
- [lte_ofdm_demodulator_mimo_2tx_0, '0', lte_sss_sync_freq_domain_mimo_2tx_0, '0']
- [lte_ofdm_demodulator_mimo_2tx_0, '1', lte_sss_sync_freq_domain_mimo_2tx_0, '1']
- [lte_pbch_decoder_mimo_4tx_0, '0', lte_bch_decoder_0, '0']
- [lte_pss_sync_direct_mimo_2tx_0, '0', lte_cp_ffo_sync_mimo_2tx_0, '0']
- [lte_pss_sync_direct_mimo_2tx_0, '0', lte_ofdm_demodulator_mimo_2tx_0, '0']
- [lte_pss_sync_direct_mimo_2tx_0, '1', lte_cp_ffo_sync_mimo_2tx_0, '1']
- [lte_pss_sync_direct_mimo_2tx_0, '1', lte_ofdm_demodulator_mimo_2tx_0, '1']
- [lte_pss_sync_direct_mimo_2tx_0, N_id_2, lte_sss_sync_freq_domain_mimo_2tx_0, N_id_2]
- [lte_sss_sync_freq_domain_mimo_2tx_0, '0', blocks_streams_to_vector_0_0, '0']
- [lte_sss_sync_freq_domain_mimo_2tx_0, '1', blocks_streams_to_vector_0_0, '1']
- [lte_sss_sync_freq_domain_mimo_2tx_0, cell_id, lte_channel_estimator_mimo_4tx_0, cell_id]
- [lte_sss_sync_freq_domain_mimo_2tx_0, cell_id, lte_pbch_decoder_mimo_4tx_0, cell_id]
- [rational_resampler_xxx_0_0, '0', lte_pss_sync_direct_mimo_2tx_0, '1']
- [rational_resampler_xxx_0_1, '0', lte_pss_sync_direct_mimo_2tx_0, '0']

metadata:
  file_format: 1
