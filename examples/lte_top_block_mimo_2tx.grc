options:
  parameters:
    author: Kristian Maier, Johannes Demel
    category: Custom
    description: LTE decoding up to 2 tx antennas
    generate_options: qt_gui
    id: lte_top_block_mimo_2tx
    output_language: python
    title: LTE top level flowgraph MIMO 2TX
  states: {}

blocks:
- name: N_rb_dl
  id: variable
  parameters:
    value: '6'
  states: {}
- name: fftl
  id: variable
  parameters:
    value: '128'
  states: {}
- name: frame_key
  id: variable
  parameters:
    value: '"slot"'
  states: {}
- name: resampler
  id: variable
  parameters:
    value: '400'
  states: {}
- name: rxant
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: fftl*15e3
  states: {}
- name: MIB
  id: lte_mib_unpack_vbm
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/johannes/src/gr-lte/tests/lte_test_data_RX2_NRBDL6.dat
    repeat: 'True'
    type: complex
    vlen: '2'
  states: {}
- name: blocks_streams_to_vector_sss_2tx
  id: blocks_streams_to_vector
  parameters:
    type: complex
    vlen: 12 * N_rb_dl
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '2'
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: lte_bch_decoder_0
  id: lte_bch_decoder
  parameters: {}
  states: {}
- name: lte_channel_estimator_mimo_2tx_0
  id: lte_channel_estimator_mimo_2tx
  parameters:
    N_rb_dl: N_rb_dl
    estimator_key: '"slot"'
    initial_id: '111'
    rxant: rxant
  states: {}
- name: lte_cp_ffo_sync_mimo_2tx_0
  id: lte_cp_ffo_sync_mimo_2tx
  parameters:
    fftlen: fftl
    rxant: rxant
  states: {}
- name: lte_ofdm_demodulator_mimo_2tx_0
  id: lte_ofdm_demodulator_mimo_2tx
  parameters:
    N_rb_dl: N_rb_dl
    fftlen: fftl
    ofdm_key: '"slot"'
    rxant: rxant
  states: {}
- name: lte_pbch_decoder_mimo_2tx_0
  id: lte_pbch_decoder_mimo_2tx
  parameters:
    N_rb_dl: N_rb_dl
    rxant: rxant
  states: {}
- name: lte_pss_sync_direct_mimo_2tx
  id: lte_pss_sync_direct_mimo_2tx
  parameters:
    fftlen: fftl
    rxant: rxant
    synclen: '5'
  states: {}
- name: lte_sss_sync_freq_domain_mimo_2tx_0
  id: lte_sss_sync_freq_domain_mimo_2tx
  parameters:
    N_rb_dl: N_rb_dl
    rxant: rxant
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: resampler
    interp: 1536*fftl//1024
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: resampler
    interp: 1536*fftl//1024
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_streams_to_vector_sss_2tx, '0', lte_channel_estimator_mimo_2tx_0, '0']
- [blocks_streams_to_vector_sss_2tx, '0', lte_pbch_decoder_mimo_2tx_0, '0']
- [blocks_throttle_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_vector_to_streams_0, '0', rational_resampler_xxx_0_1, '0']
- [blocks_vector_to_streams_0, '1', rational_resampler_xxx_0_0, '0']
- [lte_bch_decoder_0, '0', MIB, '0']
- [lte_bch_decoder_0, '1', MIB, '1']
- [lte_channel_estimator_mimo_2tx_0, '0', lte_pbch_decoder_mimo_2tx_0, '1']
- [lte_channel_estimator_mimo_2tx_0, '1', lte_pbch_decoder_mimo_2tx_0, '2']
- [lte_cp_ffo_sync_mimo_2tx_0, '0', lte_ofdm_demodulator_mimo_2tx_0, '0']
- [lte_cp_ffo_sync_mimo_2tx_0, '1', lte_ofdm_demodulator_mimo_2tx_0, '1']
- [lte_ofdm_demodulator_mimo_2tx_0, '0', lte_sss_sync_freq_domain_mimo_2tx_0, '0']
- [lte_ofdm_demodulator_mimo_2tx_0, '1', lte_sss_sync_freq_domain_mimo_2tx_0, '1']
- [lte_pbch_decoder_mimo_2tx_0, '0', lte_bch_decoder_0, '0']
- [lte_pss_sync_direct_mimo_2tx, '0', lte_cp_ffo_sync_mimo_2tx_0, '0']
- [lte_pss_sync_direct_mimo_2tx, '1', lte_cp_ffo_sync_mimo_2tx_0, '1']
- [lte_pss_sync_direct_mimo_2tx, N_id_2, lte_sss_sync_freq_domain_mimo_2tx_0, N_id_2]
- [lte_sss_sync_freq_domain_mimo_2tx_0, '0', blocks_streams_to_vector_sss_2tx, '0']
- [lte_sss_sync_freq_domain_mimo_2tx_0, '1', blocks_streams_to_vector_sss_2tx, '1']
- [lte_sss_sync_freq_domain_mimo_2tx_0, cell_id, lte_channel_estimator_mimo_2tx_0, cell_id]
- [lte_sss_sync_freq_domain_mimo_2tx_0, cell_id, lte_pbch_decoder_mimo_2tx_0, cell_id]
- [rational_resampler_xxx_0_0, '0', lte_pss_sync_direct_mimo_2tx, '1']
- [rational_resampler_xxx_0_1, '0', lte_pss_sync_direct_mimo_2tx, '0']

metadata:
  file_format: 1
