options:
  parameters:
    author: Kristian Maier, Johannes Demel
    category: lte
    generate_options: hb
    id: lte_pbch_decoder_mimo_4tx
    output_language: python
    title: PBCH Decoder MIMO 4TX
  states: {}

blocks:
- name: pbch_descr_key
  id: variable
  parameters:
    value: '"descr_part"'
  states: {}
- name: style
  id: variable
  parameters:
    value: '"tx_diversity"'
  states: {}
- name: vlen
  id: variable
  parameters:
    value: '240'
  states: {}
- name: N_rb_dl
  id: parameter
  parameters:
    label: resource blocks
    type: intx
    value: '50'
  states: {}
- name: lte_pbch_demux_vcvc_0
  id: lte_pbch_demux_vcvc
  parameters:
    N_rb_dl: N_rb_dl
    rxant: '2'
  states: {}
- name: lte_pbch_demux_vcvc_0_0
  id: lte_pbch_demux_vcvc
  parameters:
    N_rb_dl: N_rb_dl
    rxant: '2'
  states: {}
- name: lte_pbch_demux_vcvc_0_1
  id: lte_pbch_demux_vcvc
  parameters:
    N_rb_dl: N_rb_dl
    rxant: '2'
  states: {}
- name: lte_pbch_demux_vcvc_0_2
  id: lte_pbch_demux_vcvc
  parameters:
    N_rb_dl: N_rb_dl
    rxant: '2'
  states: {}
- name: lte_pbch_demux_vcvc_0_3
  id: lte_pbch_demux_vcvc
  parameters:
    N_rb_dl: N_rb_dl
    rxant: '2'
  states: {}
- name: lte_pbch_descrambler_0
  id: lte_pbch_descrambler
  parameters: {}
  states: {}
- name: lte_pre_decoder_vcvc_0
  id: lte_pre_decoder_vcvc
  parameters:
    N_ant: '1'
    rxant: '2'
    style: style
    vlen: vlen
  states: {}
- name: lte_pre_decoder_vcvc_0_0
  id: lte_pre_decoder_vcvc
  parameters:
    N_ant: '2'
    rxant: '2'
    style: style
    vlen: vlen
  states: {}
- name: lte_pre_decoder_vcvc_0_0_0
  id: lte_pre_decoder_vcvc
  parameters:
    N_ant: '4'
    rxant: '2'
    style: style
    vlen: vlen
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
    vlen: '120'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
    vlen: 12*N_rb_dl*rxant
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: ant_p0_est
    type: complex
    vlen: 12*N_rb_dl*rxant
  states: {}
- name: pad_source_2
  id: pad_source
  parameters:
    label: ant_p1_est
    type: complex
    vlen: 12*N_rb_dl*rxant
  states: {}
- name: pad_source_3
  id: pad_source
  parameters:
    label: ant_p2_est
    type: complex
    vlen: 12*N_rb_dl*rxant
  states: {}
- name: pad_source_4
  id: pad_source
  parameters:
    label: ant_p3_est
    type: complex
    vlen: 12*N_rb_dl*rxant
  states: {}
- name: pbch_blocks_interleave_0
  id: blocks_interleave
  parameters:
    num_streams: '3'
    type: complex
    vlen: vlen
  states: {}
- name: pbch_layer_demapper_vcvc_0
  id: lte_layer_demapper_vcvc
  parameters:
    N_ant: '1'
    style: style
    vlen: vlen
  states: {}
- name: pbch_layer_demapper_vcvc_1
  id: lte_layer_demapper_vcvc
  parameters:
    N_ant: '2'
    style: style
    vlen: vlen
  states: {}
- name: pbch_layer_demapper_vcvc_1_0
  id: lte_layer_demapper_vcvc
  parameters:
    N_ant: '4'
    style: style
    vlen: vlen
  states: {}
- name: pbch_qpsk_soft_demod_vcvf_0
  id: lte_qpsk_soft_demod_vcvf
  parameters:
    vlen: vlen
  states: {}
- name: rxant
  id: parameter
  parameters:
    label: RX antennas
    type: intx
    value: '2'
  states: {}
- name: z_pad_source_cell_id
  id: pad_source
  parameters:
    label: cell_id
    type: message
  states: {}

connections:
- [lte_pbch_demux_vcvc_0, '0', lte_pre_decoder_vcvc_0, '0']
- [lte_pbch_demux_vcvc_0, '0', lte_pre_decoder_vcvc_0_0, '0']
- [lte_pbch_demux_vcvc_0, '0', lte_pre_decoder_vcvc_0_0_0, '0']
- [lte_pbch_demux_vcvc_0_0, '0', lte_pre_decoder_vcvc_0_0_0, '4']
- [lte_pbch_demux_vcvc_0_1, '0', lte_pre_decoder_vcvc_0_0_0, '3']
- [lte_pbch_demux_vcvc_0_2, '0', lte_pre_decoder_vcvc_0_0, '2']
- [lte_pbch_demux_vcvc_0_2, '0', lte_pre_decoder_vcvc_0_0_0, '2']
- [lte_pbch_demux_vcvc_0_3, '0', lte_pre_decoder_vcvc_0, '1']
- [lte_pbch_demux_vcvc_0_3, '0', lte_pre_decoder_vcvc_0_0, '1']
- [lte_pbch_demux_vcvc_0_3, '0', lte_pre_decoder_vcvc_0_0_0, '1']
- [lte_pbch_descrambler_0, '0', pad_sink_0, '0']
- [lte_pre_decoder_vcvc_0, '0', pbch_layer_demapper_vcvc_0, '0']
- [lte_pre_decoder_vcvc_0_0, '0', pbch_layer_demapper_vcvc_1, '0']
- [lte_pre_decoder_vcvc_0_0_0, '0', pbch_layer_demapper_vcvc_1_0, '0']
- [pad_source_0, '0', lte_pbch_demux_vcvc_0, '0']
- [pad_source_1, '0', lte_pbch_demux_vcvc_0_3, '0']
- [pad_source_2, '0', lte_pbch_demux_vcvc_0_2, '0']
- [pad_source_3, '0', lte_pbch_demux_vcvc_0_1, '0']
- [pad_source_4, '0', lte_pbch_demux_vcvc_0_0, '0']
- [pbch_blocks_interleave_0, '0', pbch_qpsk_soft_demod_vcvf_0, '0']
- [pbch_layer_demapper_vcvc_0, '0', pbch_blocks_interleave_0, '0']
- [pbch_layer_demapper_vcvc_1, '0', pbch_blocks_interleave_0, '1']
- [pbch_layer_demapper_vcvc_1_0, '0', pbch_blocks_interleave_0, '2']
- [pbch_qpsk_soft_demod_vcvf_0, '0', lte_pbch_descrambler_0, '0']
- [z_pad_source_cell_id, out, lte_pbch_demux_vcvc_0, cell_id]
- [z_pad_source_cell_id, out, lte_pbch_demux_vcvc_0_0, cell_id]
- [z_pad_source_cell_id, out, lte_pbch_demux_vcvc_0_1, cell_id]
- [z_pad_source_cell_id, out, lte_pbch_demux_vcvc_0_2, cell_id]
- [z_pad_source_cell_id, out, lte_pbch_demux_vcvc_0_3, cell_id]
- [z_pad_source_cell_id, out, lte_pbch_descrambler_0, cell_id]

metadata:
  file_format: 1
