options:
  parameters:
    author: Kristian Maier
    category: lte
    generate_options: hb
    id: lte_sss_sync_freq_domain_mimo_2tx
    output_language: python
    title: SSS Sync frequency Domain MIMO 2TX
  states: {}

blocks:
- name: N_rb_dl
  id: parameter
  parameters:
    label: resource blocks
    type: intx
    value: '50'
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
    vlen: '72'
  states: {}
- name: lte_mimo_sss_calculator_0
  id: lte_mimo_sss_calculator
  parameters:
    rxant: rxant
  states: {}
- name: lte_mimo_sss_symbol_selector_0_0
  id: lte_mimo_sss_symbol_selector
  parameters:
    N_rb_dl: N_rb_dl
    rxant: '1'
  states: {}
- name: lte_mimo_sss_symbol_selector_0_0_0
  id: lte_mimo_sss_symbol_selector
  parameters:
    N_rb_dl: N_rb_dl
    rxant: '1'
  states: {}
- name: lte_mimo_sss_tagger_0
  id: lte_mimo_sss_tagger
  parameters:
    N_rb_dl: N_rb_dl
    rxant: '1'
  states: {}
- name: lte_mimo_sss_tagger_0_0
  id: lte_mimo_sss_tagger
  parameters:
    N_rb_dl: N_rb_dl
    rxant: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    num_streams: rxant
    type: complex
    vlen: N_rb_dl*12
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: cell_id
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    num_streams: rxant
    type: complex
    vlen: N_rb_dl*12
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: N_id_2
    type: message
  states: {}
- name: rxant
  id: parameter
  parameters:
    label: RX antennas
    type: intx
    value: '2'
  states: {}

connections:
- [blocks_streams_to_vector_0, '0', lte_mimo_sss_calculator_0, '0']
- [lte_mimo_sss_calculator_0, cell_id, pad_sink_0_0_0, in]
- [lte_mimo_sss_calculator_0, frame_start, lte_mimo_sss_tagger_0, frame_start]
- [lte_mimo_sss_calculator_0, frame_start, lte_mimo_sss_tagger_0_0, frame_start]
- [lte_mimo_sss_symbol_selector_0_0, '0', blocks_streams_to_vector_0, '0']
- [lte_mimo_sss_symbol_selector_0_0_0, '0', blocks_streams_to_vector_0, '1']
- [lte_mimo_sss_tagger_0, '0', pad_sink_0, '0']
- [lte_mimo_sss_tagger_0_0, '0', pad_sink_0, '1']
- [pad_source_0, '0', lte_mimo_sss_symbol_selector_0_0, '0']
- [pad_source_0, '0', lte_mimo_sss_tagger_0, '0']
- [pad_source_0, '1', lte_mimo_sss_symbol_selector_0_0_0, '0']
- [pad_source_0, '1', lte_mimo_sss_tagger_0_0, '0']
- [pad_source_1, out, lte_mimo_sss_calculator_0, N_id_2]

metadata:
  file_format: 1
