options:
  parameters:
    author: Kristian Maier
    category: lte
    generate_options: hb
    id: lte_cp_ffo_sync_mimo_2tx
    output_language: python
    title: PSS-based CP Sync MIMO 2TX
  states: {}

blocks:
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: fftlen
  id: parameter
  parameters:
    label: FFT length
    type: intx
    value: '1024'
  states: {}
- name: lte_mimo_pss_freq_sync_0
  id: lte_mimo_pss_freq_sync
  parameters:
    fftl: fftlen
    rxant: rxant
    sig: '"sync_ffofrac_sig"'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    num_streams: rxant
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    num_streams: rxant
    type: complex
  states: {}
- name: rxant
  id: parameter
  parameters:
    label: RX antennas
    type: intx
    value: '2'
  states: {}
- name: sync_ffofrac_sig
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: fftlen*15e3
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}

connections:
- [blocks_multiply_xx_0, '0', lte_mimo_pss_freq_sync_0, '0']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', lte_mimo_pss_freq_sync_0, '1']
- [blocks_multiply_xx_0_0, '0', pad_sink_0, '1']
- [lte_mimo_pss_freq_sync_0, freq, sync_ffofrac_sig, cmd]
- [pad_source_0, '0', blocks_multiply_xx_0, '0']
- [pad_source_0, '1', blocks_multiply_xx_0_0, '0']
- [sync_ffofrac_sig, '0', blocks_multiply_xx_0, '1']
- [sync_ffofrac_sig, '0', blocks_multiply_xx_0_0, '1']

metadata:
  file_format: 1
